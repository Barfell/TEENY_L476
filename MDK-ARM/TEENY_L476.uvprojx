# Keil uVision project TEENY_L476.uvprojx, settings and files
target TEENY_L476 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TEENY_L476 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,NO_HOST
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\teeny_stack\core;..\teeny_stack\class\user;..\teeny_stack\class\cdc;..\teeny_stack\class\msc;..\teeny_stack\class\hid;..\teeny_stack\class;..\teeny_stack\driver_stm32;..\teeny_stack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c gpio.c usart.c usb_otg.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group teeny_usb_stack
    ../teeny_stack/core/: teeny_usb_retarget.c teeny_usb_device.c
  group usb_driver
    ../teeny_stack/driver_stm32/: tusb_dev_drv_stm32_otg.c tusb_dev_drv_stm32_fs.c tusb_drv_stm32_otg_common.c
    ../teeny_stack/: board.c
  group app
    ../teeny_stack/: teeny_usb_desc.c composite_device.c composite_desc.lua composite_device_ram_fat16.c
  group usb_device
    ../teeny_stack/class/: tusbd.c
    ../teeny_stack/class/user/: tusbd_user.c
    ../teeny_stack/class/msc/: tusbd_msc.c
    ../teeny_stack/class/hid/: tusbd_hid.c
    ../teeny_stack/class/cdc/: tusbd_cdc.c tusbd_cdc_rndis.c
software components: CMSIS:CORE 4.3.0
